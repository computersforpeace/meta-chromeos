do_install:append() {
    # TODO: Installed this by chromeos-auth-config instead.
    #rm -f "${D}${sysconfdir}/pam.d/login"
    :
}
