FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://protobuf-3.16.0-protoc_input_output_files.patch"
