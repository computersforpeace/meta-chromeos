FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://udev-225-udevadm-trigger-add-settle.patch \
"
